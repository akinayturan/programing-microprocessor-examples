LIST P=16F84A
INCLUDE P16F84A.INC

__CONFIG _CP_OFF & _WDT_OFF & _PWRTE_ON & _RC_OSC

BSF STATUS,5
CLRF TRISA
CLRF TRISB
BCF STATUS,5
CLRF PORTB

TEST
	BTFSS PORTA,1
	GOTO TEST2
	GOTO YAK1
	
TEST2
	BTFSS PORTA,2
	GOTO TEST3
	GOTO YAK2

TEST3
	BTFSS PORTA,3
	GOTO TEST
	GOTO YAK3

YAK1
	MOVLW B'00110000'
	MOVWF PORTB
LOOP GOTO LOOP

YAK2
	MOVLW B'01101101'
	MOVWF PORTB
LOOP2 GOTO LOOP2

YAK3
	MOVLW B'01111001'
	MOVWF PORTB
LOOP3 GOTO LOOP3

END
 